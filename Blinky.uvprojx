# Keil uVision project Blinky.uvprojx, settings and files
target TM4C129 RAM (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x20030000 size 0x10000
  group Source Files
    ./: Retarget.c Serial.c BTN.c LED.c Blinky.c SYSTICK.c
  group Documentation
    ./: Abstract.txt
target TM4C129 Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
